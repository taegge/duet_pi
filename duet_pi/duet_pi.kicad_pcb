# Repository taegge/duet_pi

File README.md:

# Purpose

This is a Rasperry Pi CM4/CM5 carrier board for elegantly interfacing an SBC to the Duet3d Duet 3 6HC (https://www.duet3d.com/duet3mainboard6hc). Intended to be mounted back-to-back, the footprint and mounting holes are identical. In that configuration, the 26 pin IO connectors are also directly inline, supporting either a short wire or direct board-to-board connection.

## Features
 * Same input voltage range as Duet 3 6HC: 12V-48V (Vin)
 * Onboard 5V @ 5A regulatoin for raspberry pi and accessories.
 * Onboard selectable 12V / 24V @ 5A regulator  (Vreg)
 * Four high current, independantly fused power distribution ports. Selectable between Vreg or Vin
 * High Speed IO: ethernet, USB A, USB C, HDMI, DSI/CSI, microSD, m.2
 * JST and Molex (5v) fan connections.

# Board Layout

# PCB Fabrication

For impedance control, pcb was designed for the specific board stackup from jlcpcb: JLC041611-3313

4 layers. 1oz copper inner and outer. 1.6mm thick

provided by https://jlcpcb.com/pcb-impedance-calculator

## KiCad design duet_pi/duet_pi.kicad_pcb

Board: 4 copper layers, 134.0 x 140.0 mm, 128 parts (12 on the bottom side), 194 nets.

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3034_1x20mm
C1, C2, C3, C5, C6, C11, C14, C23, C34: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C7, C9, C10, C12, C13, C16, C17, C18, C19: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 100uF; CP_EIA-7343-31_Kemet-D
C15, C29, C40: 4.7nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20, C21, C24, C25, C26, C31, C32, C35, C36, C37: 10uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C22, C33: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C27, C38: 10000pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28, C39: 47pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D3: LED Green; LED_0603_1608Metric
D2: LED Red; LED_0603_1608Metric
D4, D5: D_Schottky; D_SMA_Handsoldering
F1, F2, F3, F4: MCCQ-122
H1, H2, H3, H4: MountingHole_4.3mm_M4
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: THD-20-R; PinHeader_2x20_P2.54mm_Vertical
J3, J12: THD-02-R; PinHeader_2x02_P2.54mm_Vertical
J4: THD-13-R; IDC-Header_2x13_P2.54mm_Vertical
J5: Micro_SD_Card_Det; SDCARD_MOLEX_503398-1892
J6: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J7: FanPinHeader_1x04_P2.54mm_Vertical
J8: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical
J9, J13: Conn_01x22_Female; Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal
J10: 690-019-298-412; EDAC 690-019-298-412
J11: USB3_A; MTCONN_UBAF30-D2011
J14: WM1282DKR-ND; HDMI_Micro-D_Molex_46765-1x01
J15: Bus_M.2_Socket_M; M.2 M Key socket
J16: Screw_Terminal_01x10; HB9500-9.5-10p
J20: JST_SHBM04B-SRSS-TB; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
JP1, JP7, JP8: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP2, JP3, JP4, JP5: SolderJumper_3_Open; resistor_jumper_3_way_0805
JP6: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP9: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1: 2.2uH; L_Bourns_SRP5030CC
L2, L5: 8.2uH; SMD_inductor_07A7
M6: Fan; fan_40mm_M3
Module1: ComputeModule5-CM5; Raspberry-Pi-5-Compute-Module
R1, R6, R7, R8, R13: 2.2K 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R5, R10: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 470R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 15K 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 10K 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 100K 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14, R15, R21, R22: R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R23: 147k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17, R24: 240k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18: 28k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R19, R26: 3.24k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25: 5.05k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R27: 10.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: Right angle Tact button; SW_Tactile_SPST_Angled_PTS645Vx58-2LFS
TP1, TP2, TP3: TestPoint; TestPoint_Pad_2.0x2.0mm
TP4, TP5, TP6: TestPoint; TestPoint_Pad_D1.5mm
U1, U2: TPD4EUSB30; USON-10_2.5x1.0mm_P0.5mm
U3: MagJack-A70-112-331N126; TRJG0926HENL
U4: 74LVC1G07SE-7; SOT-353_SC-70-5
U5: RT9742GGJ5; SOT-23-5
U6: RT9742SNGV; TSOT-23_HandSoldering
U7: AP22653W6; SOT-23-6
U8: ASEK-32.768KHZ-L-R-T; Crystal_SMD_3225-4Pin_3.2x2.5mm
U9: AP3441SHE-7B; DFN-8-1EP_2x2mm_P0.5mm_EP1.05x1.75mm
U10, U11: TPP60508; DFN-10_EP_4x4_Pitch0.8mm

Connections:
/+3.3v: D1.2 (A), D2.2 (A), J2.1, J2.17, J4.1, J4.17, J9.22, J13.22, JP1.1 (A), Module1.84 (+3.3v_(Output)), Module1.86 (+3.3v_(Output)), R8.1, U3.15 (LEDY_A), U3.17 (LEDG_A), U4.5 (VCC), U5.5 (IN)
/+5v: C5.1, C7.1, C12.1, C13.1, C14.1, C24.1, C25.1, C26.1, J2.2, J2.4, J4.2, J4.4, J7.2, J20.1, JP9.2 (B), L2.2, Module1.77 (+5v_(Input)), Module1.79 (+5v_(Input)), Module1.81 (+5v_(Input)), Module1.83 (+5v_(Input)), Module1.85 (+5v_(Input)), Module1.87 (+5v_(Input)), R16.2, TP4.1, U6.1 (IN), U7.1 (IN), U9.3 (VIN)
/CC1: J1.A5 (CC1), Module1.94 (CC1)
/CC2: J1.B5 (CC2), Module1.96 (CC2)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/+1.8v: JP1.3 (B), Module1.88 (+1.8v_(Output)), Module1.90 (+1.8v_(Output))
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/BT_nDis: J6.3, Module1.91 (BT_nDisable)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/CAM_GPIO0: J9.17, Module1.97 (CAM_GPIO0)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/CAM_GPIO1: J9.18, Module1.100 (CAM_GPIO1)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/EEPROM_nWP: J8.4, Module1.20 (EEPROM_nWP)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/ETH_LEDG: Module1.17 (Ethernet_nLED2(3.3v)), R3.2
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/ETH_LEDY: Module1.15 (Ethernet_nLED3(3.3v)), R4.2
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO2: J2.3, J4.3, Module1.58 (GPIO2)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO3: J2.5, J4.5, Module1.56 (GPIO3)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO4: J2.7, J4.7, Module1.54 (GPIO4)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO5: J2.29, Module1.34 (GPIO5)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO6: J2.31, Module1.30 (GPIO6)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO7: J2.26, J4.26, Module1.37 (GPIO7)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO8: J2.24, J4.24, Module1.39 (GPIO8)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO9: J2.21, J4.21, Module1.40 (GPIO9)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO10: J2.19, J4.19, Module1.44 (GPIO10)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO11: J2.23, J4.23, Module1.38 (GPIO11)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO12: J2.32, Module1.31 (GPIO12)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO13: J2.33, Module1.28 (GPIO13)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO14: J2.8, J4.8, Module1.55 (GPIO14)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO15: J2.10, J4.10, Module1.51 (GPIO15)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO16: J2.36, Module1.29 (GPIO16)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO17: J2.11, J4.11, Module1.50 (GPIO17)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO18: J2.12, J4.12, Module1.49 (GPIO18)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO19: J2.35, Module1.26 (GPIO19)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO20: J2.38, Module1.27 (GPIO20)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO21: J2.40, Module1.25 (GPIO21)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO22: J2.15, J4.15, Module1.46 (GPIO22)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO23: J2.16, J4.16, Module1.47 (GPIO23)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO24: J2.18, J4.18, Module1.45 (GPIO24)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO25: J2.22, J4.22, Module1.41 (GPIO25)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO26: J2.37, Module1.24 (GPIO26)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO27: J2.13, J4.13, Module1.48 (GPIO27)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/GPIO_VREF: JP1.2 (C), Module1.78 (GPIO_VREF(1.8v/3.3v_Input)), R6.1, R7.1
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/ID_SC: J2.28, J12.1, Module1.35 (ID_SC)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/ID_SD: J2.27, J12.3, Module1.36 (ID_SD)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/PMIC_ENABLE: J8.12, Module1.99 (PMIC_ENABLE)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/PWM: JP7.2 (C), Module1.19 (FAN_PWM)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/PWR_BUT: J8.14, Module1.92 (PWR_BUT), SW1.1
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/SD_CLK: J5.5 (CLK), Module1.57 (SD_CLK)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/SD_CMD: J5.3 (CMD), Module1.62 (SD_CMD)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT0: J5.7 (DAT0), Module1.63 (SD_DAT0)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT1: J5.8 (DAT1), Module1.67 (SD_DAT1)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT2: J5.1 (DAT2), Module1.69 (SD_DAT2)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT3: J5.2 (DAT3/CD), Module1.61 (SD_DAT3)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/SD_PWR: C4.1, J5.4 (VDD), U5.1 (OUT)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/SD_PWR_ON: Module1.75 (SD_PWR_ON), U5.4 (EN)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/SYNC_OUT: J8.6, Module1.18 (Ethernet_SYNC_OUT(3.3v))
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TACHO: JP8.2 (C), Module1.16 (FAN_TACHO)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TR0_TAP: J3.3, U3.11 (VC1)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TR1_TAP: J3.1, U3.12 (VC2)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TR2_TAP: J3.2, U3.13 (VC3)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TR3_TAP: J3.4, U3.14 (VC4)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TRD0_N: Module1.10 (Ethernet_Pair0_N), U2.4 (D2+), U2.7, U3.2 (TRD0-)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TRD0_P: Module1.12 (Ethernet_Pair0_P), U2.5 (D2-), U2.6, U3.1 (TRD0+)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TRD1_N: Module1.6 (Ethernet_Pair1_N), U2.2 (D1-), U2.9, U3.6 (TRD1-)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TRD1_P: Module1.4 (Ethernet_Pair1_P), U2.1 (D1+), U2.10, U3.3 (TRD1+)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TRD2_N: Module1.9 (Ethernet_Pair2_N), U1.4 (D2+), U1.7, U3.8 (TRD2-)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TRD2_P: Module1.11 (Ethernet_Pair2_P), U1.5 (D2-), U1.6, U3.7 (TRD2+)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TRD3_N: Module1.5 (Ethernet_Pair3_N), U1.2 (D1-), U1.9, U3.10 (TRD3-)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/TRD3_P: Module1.3 (Ethernet_Pair3_P), U1.1 (D1+), U1.10, U3.9 (TRD3+)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/USBOTG: J8.10, Module1.101 (USB_OTG_ID)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/VBAT: BT1.1 (+), Module1.76 (VBAT)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/WL_nDis: J6.1, Module1.89 (WiFi_nDisable)
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/nPWR_LED: Module1.95 (LED_nPWR), U4.2
/CM5_GPIO ( Ethernet, GPIO, SDCARD)/nRPIBOOT: J8.2, Module1.93 (nRPIBOOT)
/CM5_HighSpeed/DPHY0_C_N: J9.8, Module1.127 (MIPI0_C_N)
/CM5_HighSpeed/DPHY0_C_P: J9.9, Module1.129 (MIPI0_C_P)
/CM5_HighSpeed/DPHY0_D0_N: J9.2, Module1.115 (MIPI0_D0_N)
/CM5_HighSpeed/DPHY0_D0_P: J9.3, Module1.117 (MIPI0_D0_P)
/CM5_HighSpeed/DPHY0_D1_N: J9.5, Module1.121 (MIPI0_D1_N)
/CM5_HighSpeed/DPHY0_D1_P: J9.6, Module1.123 (MIPI0_D1_P)
/CM5_HighSpeed/DPHY0_D2_N: J9.11, Module1.133 (MIPI0_D2_N)
/CM5_HighSpeed/DPHY0_D2_P: J9.12, Module1.135 (MIPI0_D2_P)
/CM5_HighSpeed/DPHY0_D3_N: J9.14, Module1.139 (MIPI0_D3_N)
/CM5_HighSpeed/DPHY0_D3_P: J9.15, Module1.141 (MIPI0_D3_P)
/CM5_HighSpeed/DPHY1_C_N: J13.8, Module1.187 (MIPI1_C_N)
/CM5_HighSpeed/DPHY1_C_P: J13.9, Module1.189 (MIPI1_C_P)
/CM5_HighSpeed/DPHY1_D0_N: J13.2, Module1.175 (MIPI1_D0_N)
/CM5_HighSpeed/DPHY1_D0_P: J13.3, Module1.177 (MIPI1_D0_P)
/CM5_HighSpeed/DPHY1_D1_N: J13.5, Module1.181 (MIPI1_D1_N)
/CM5_HighSpeed/DPHY1_D1_P: J13.6, Module1.183 (MIPI1_D1_P)
/CM5_HighSpeed/DPHY1_D2_N: J13.11, Module1.193 (MIPI1_D2_N)
/CM5_HighSpeed/DPHY1_D2_P: J13.12, Module1.195 (MIPI1_D2_P)
/CM5_HighSpeed/DPHY1_D3_N: J13.14, Module1.194 (MIPI1_D3_N)
/CM5_HighSpeed/DPHY1_D3_P: J13.15, Module1.196 (MIPI1_D3_P)
/CM5_HighSpeed/HDMI0_CEC: J10.13 (CEC), Module1.151 (HDMI0_CEC)
/CM5_HighSpeed/HDMI0_CK_N: J10.12 (CK-), Module1.190 (HDMI0_CLK_N)
/CM5_HighSpeed/HDMI0_CK_P: J10.10 (CK+), Module1.188 (HDMI0_CLK_P)
/CM5_HighSpeed/HDMI0_D0_N: J10.9 (D0-), Module1.184 (HDMI0_TX0_N)
/CM5_HighSpeed/HDMI0_D0_P: J10.7 (D0+), Module1.182 (HDMI0_TX0_P)
/CM5_HighSpeed/HDMI0_D1_N: J10.6 (D1-), Module1.178 (HDMI0_TX1_N)
/CM5_HighSpeed/HDMI0_D1_P: J10.4 (D1+), Module1.176 (HDMI0_TX1_P)
/CM5_HighSpeed/HDMI0_D2_N: J10.3 (D2-), Module1.172 (HDMI0_TX2_N)
/CM5_HighSpeed/HDMI0_D2_P: J10.1 (D2+), Module1.170 (HDMI0_TX2_P)
/CM5_HighSpeed/HDMI0_HOTPLUG: J10.19 (HPD/HEAC-), Module1.153 (HDMI0_HOTPLUG)
/CM5_HighSpeed/HDMI0_SCL: J10.15 (SCL), Module1.200 (HDMI0_SCL)
/CM5_HighSpeed/HDMI0_SDA: J10.16 (SDA), Module1.199 (HDMI0_SDA)
/CM5_HighSpeed/HDMI1_CEC: J14.13 (CEC), Module1.149 (HDMI1_CEC)
/CM5_HighSpeed/HDMI1_CK_N: J14.12 (CK-), Module1.166 (HDMI1_CLK_N)
/CM5_HighSpeed/HDMI1_CK_P: J14.10 (CK+), Module1.164 (HDMI1_CLK_P)
/CM5_HighSpeed/HDMI1_D0_N: J14.9 (D0-), Module1.160 (HDMI1_TX0_N)
/CM5_HighSpeed/HDMI1_D0_P: J14.7 (D0+), Module1.158 (HDMI1_TX0_P)
/CM5_HighSpeed/HDMI1_D1_N: J14.6 (D1-), Module1.154 (HDMI1_TX1_N)
/CM5_HighSpeed/HDMI1_D1_P: J14.4 (D1+), Module1.152 (HDMI1_TX1_P)
/CM5_HighSpeed/HDMI1_D2_N: J14.3 (D2-), Module1.148 (HDMI1_TX2_N)
/CM5_HighSpeed/HDMI1_D2_P: J14.1 (D2+), Module1.146 (HDMI1_TX2_P)
/CM5_HighSpeed/HDMI1_HOTPLUG: J14.19 (HPD/HEAC-), Module1.143 (HDMI1_HOTPLUG)
/CM5_HighSpeed/HDMI1_SCL: J14.15 (SCL), Module1.147 (HDMI1_SCL)
/CM5_HighSpeed/HDMI1_SDA: J14.16 (SDA), Module1.145 (HDMI1_SDA)
/CM5_HighSpeed/HDMI_5v: C6.1, J10.18 (+5V), J14.18 (+5V), U6.2 (OUT)
/CM5_HighSpeed/PCIE_CLK_N: J15.53 (REFCLKn), Module1.112 (PCIe_CLK_N)
/CM5_HighSpeed/PCIE_CLK_P: J15.55 (REFCLKp), Module1.110 (PCIe_CLK_P)
/CM5_HighSpeed/PCIE_PWR_EN: Module1.106 (PCIE_PWR_EN), R12.1, U9.7 (EN)
/CM5_HighSpeed/PCIE_RX_N: J15.43 (PETp0), Module1.118 (PCIe_RX_N)
/CM5_HighSpeed/PCIE_RX_P: J15.41 (PETn0), Module1.116 (PCIe_RX_P)
/CM5_HighSpeed/PCIE_TX_N: J15.49 (PERp0), Module1.124 (PCIe_TX_N)
/CM5_HighSpeed/PCIE_TX_P: J15.47 (PERn0), Module1.122 (PCIe_TX_P)
/CM5_HighSpeed/PCIE_nCLKREQ: J15.52 (~CLKREQ), Module1.102 (PCIe_nCLKREQ)
/CM5_HighSpeed/PCIE_nRST: J15.50 (~PERST), Module1.109 (PCIe_nRST)
/CM5_HighSpeed/PCIE_nWAKE: J15.54 (~PEWAKE), Module1.104 (PCIE_nWAKE)
/CM5_HighSpeed/SCL0: J9.20, Module1.80 (SCL0)
/CM5_HighSpeed/SCL1: J12.2, J13.20, R7.2
/CM5_HighSpeed/SDA0: J9.21, Module1.82 (SDA0)
/CM5_HighSpeed/SDA1: J12.4, J13.21, R6.2
/CM5_HighSpeed/USB3-0-D_N: J11.A2 (D-), Module1.136 (USB3-0-D_N)
/CM5_HighSpeed/USB3-0-D_P: J11.A3 (D+), Module1.134 (USB3-0-D_P)
/CM5_HighSpeed/USB3-0-RX_N: J11.A6 (SSRX+), Module1.128 (USB3-0-RX_N)
/CM5_HighSpeed/USB3-0-RX_P: J11.A5 (SSRX-), Module1.130 (USB3-0-RX_P)
/CM5_HighSpeed/USB3-0-TX_N: J11.A9 (SSTX+), Module1.140 (USB3-0-TX_N)
/CM5_HighSpeed/USB3-0-TX_P: J11.A8 (SSTX-), Module1.142 (USB3-0-TX_P)
/CM5_HighSpeed/USB3-1-D_N: J11.B2 (D-), Module1.165 (USB3-1-D_N)
/CM5_HighSpeed/USB3-1-D_P: J11.B3 (D+), Module1.163 (USB3-1-D_P)
/CM5_HighSpeed/USB3-1-RX_N: J11.B6 (SSRX+), Module1.157 (USB3-1-RX_N)
/CM5_HighSpeed/USB3-1-RX_P: J11.B5 (SSRX-), Module1.159 (USB3-1-RX_P)
/CM5_HighSpeed/USB3-1-TX_N: J11.B9 (SSTX+), Module1.169 (USB3-1-TX_N)
/CM5_HighSpeed/USB3-1-TX_P: J11.B8 (SSTX-), Module1.171 (USB3-1-TX_P)
/CM5_HighSpeed/VBUS: C8.1, C9.1, C10.1, J11.A1 (VBUS), J11.B1 (VBUS), U7.6 (OUT)
/CM5_HighSpeed/VBUS_EN: Module1.111 (VBUS_EN), U7.3 (EN)
/PCIe-M2/FB: C15.2, R11.2, R13.1, U9.1 (FB)
/PCIe-M2/M2_3v3: C11.1, C15.1, C16.1, C17.1, C18.1, C19.1, D3.2 (A), J15.2 (3.3V), J15.4 (3.3V), J15.12 (3.3V), J15.14 (3.3V), J15.16 (3.3V), J15.18 (3.3V), J15.70 (3.3V), J15.72 (3.3V), J15.74 (3.3V), L1.2, R11.1, TP6.1, U8.1 (EN), U8.4 (VDD)
/USB2_N: J1.A7 (D-), J1.B7 (D-), Module1.103 (USB2_N)
/USB2_P: J1.A6 (D+), J1.B6 (D+), Module1.105 (USB2_P)
/misc/R_fb_12: JP6.3 (B), R27.2
/misc/R_fb_24: JP6.1 (A), R25.2
/misc/Vin: C20.1, C21.1, C22.1, C31.1, C32.1, C33.1, J16.10, JP2.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), R14.1, R21.1, U10.2 (VIN), U11.2 (VIN)
/misc/Vreg2: C35.1, C36.1, C37.1, JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), L5.2, R23.2, TP5.1
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C31.2, C32.2, C33.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, D4.2 (A), D5.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.6, J2.9, J2.14, J2.20, J2.25, J2.30, J2.34, J2.39, J4.6, J4.9, J4.14, J4.20, J4.25, J5.6 (VSS), J5.11 (SHIELD), J6.2, J7.1, J8.1, J8.3, J8.5, J8.7, J8.9, J8.11, J8.13, J9.1, J9.4, J9.7, J9.10, J9.13, J9.16, J9.19, J10.2 (D2S), J10.5 (D1S), J10.8 (D0S), J10.11 (CKS), J10.17 (GND)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
unnamed: C3.1, U3.4 (CT), U3.5 (CT)
unnamed: C29.1, R19.1
unnamed: C40.1, R26.1
unnamed: D1.1 (K), R2.1, TP1.1
unnamed: D2.1 (K), R5.1, TP2.1
unnamed: D3.1 (K), R10.1, TP3.1
unnamed: C23.2, D4.1 (K), L2.1, U10.9 (SW)
unnamed: C34.2, D5.1 (K), L5.1, U11.9 (SW)
unnamed: J7.3, JP8.3 (B)
unnamed: J7.4, JP7.3 (B)
unnamed: J13.17, R8.2
unnamed: J15.10 (DAS/~DSS/~LED1), R10.2
unnamed: J15.68 (SUSCLK), U8.3 (Out)
unnamed: F4.1, J16.2
unnamed: F3.1, J16.4
unnamed: F2.1, J16.6
unnamed: F1.1, J16.8
unnamed: J20.2, JP7.1 (A)
unnamed: J20.4, JP8.1 (A)
unnamed: F1.2, JP2.2 (C)
unnamed: F2.2, JP3.2 (C)
unnamed: F3.2, JP4.2 (C)
unnamed: F4.2, JP5.2 (C)
unnamed: JP6.2 (C), R23.1, U11.6 (FB)
unnamed: C1.1, C2.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), JP9.1 (A), R1.1
unnamed: Module1.21 (LED_nACT), R2.2
unnamed: R5.2, U4.4
unnamed: R4.1, U3.18 (LEDG_K)
unnamed: R3.1, U3.16 (LEDY_K)
unnamed: R9.1, U7.5 (ILIM)
unnamed: L1.1, U9.6 (LX)
unnamed: C23.1, U10.1 (BOOT)
unnamed: C28.1, R19.2, U10.7 (COMP)
unnamed: R14.2, R15.1, U10.3 (EN)
unnamed: R16.1, R18.2, U10.6 (FB)
unnamed: R17.2, U10.5 (RT/CLT)
unnamed: C27.1, U10.4 (SS/TR)
unnamed: C34.1, U11.1 (BOOT)
unnamed: C39.1, R26.2, U11.7 (COMP)
unnamed: R21.2, R22.1, U11.3 (EN)
unnamed: R24.2, U11.5 (RT/CLT)
unnamed: C38.1, U11.4 (SS/TR)

## Commit log

2024-12-31 complete schematic
2025-01-30 stalled routing
2025-02-01 pre-revise 5v route
2025-02-01 finding a home for the battery
2025-02-01 everything routed, 4 errors
2025-02-02 differential pair matching
2025-02-02 nearing final routing
2025-02-03 incremental updates
2025-02-06 initial production
2025-02-07 v0.1 prototype definition
2025-02-07 publish
2025-02-07 organize root folder
2025-02-07 add readme.md
2025-02-07 organize root folder, improve readme
2025-02-07 improve readme
2025-02-13 fix: 5A diodes in regulation stages
2025-02-13 add to BOM: molex kk fan header, JP1 jumpers
2025-02-14 silkscreen: enlarge polarity marking
2025-02-17 fix ethernet, fan header
2025-02-18 add m.2 solder nut to BOM
2025-02-22 fix pc fan header J7

Notices in the files:
duet_pi/duet_pi.kicad_pcb:
Released under CERN-OHL-S v2 license terms.
